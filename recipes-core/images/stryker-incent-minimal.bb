SUMMARY = "Incent minimal image"
LICENSE = "MIT"
inherit incent-image
